# IAR project msa_cc2531.ewp, settings and files
configuration Normal (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2531F256.i51
  ICC8051.CCDefines: CC2531DK; POWER_SAVING; HAL_AES=FALSE; HAL_DMA=FALSE; HAL_FLASH=FALSE
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\..\..\common\CC2530; ..\..\..\..\..\Components\hal\include; ..\..\..\..\..\Components\hal\target\CC2530USB; ..\..\..\..\..\Components\hal\target\CC2530USB\usb\library; ..\..\..\..\..\Components\hal\target\CC2530USB\usb\library\cc2531; ..\..\..\..\..\Components\hal\target\CC2530USB\usb\class_cdc; ..\..\..\..\..\Components\mac\include; ..\..\..\..\..\Components\mac\high_level; ..\..\..\..\..\Components\mac\low_level\srf04; ..\..\..\..\..\Components\mac\low_level\srf04\single_chip; ..\..\..\..\..\Components\mt; ..\..\..\..\..\Components\osal\include; ..\..\..\..\..\Components\services\saddr; ..\..\..\..\..\Components\services\sdata
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: ..\..\..\common\CC2530\ti_51ew_cc2531b.xcl
configuration Secure (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: CC2531DK; POWER_SAVING; MAC_SECURITY; HAL_FLASH=FALSE
  group Application
    ../../Application/: msa.c msa.h msa_Main.c msa_Osal.c
    ../../../common/cc2530/: OnBoard.c
  group HAL/Common
    ../../../../../Components/hal/common/: hal_assert.c hal_drivers.c
  group HAL/Include
    ../../../../../Components/hal/include/: hal_adc.h hal_assert.h hal_board.h hal_defs.h hal_drivers.h hal_key.h hal_lcd.h hal_led.h hal_sleep.h hal_timer.h hal_uart.h
  group HAL/Target/CC2530USB/Config
    ../../../../../Components/hal/target/CC2530USB/: hal_board_cfg.h
  group HAL/Target/CC2530USB/Drivers
    ../../../../../Components/hal/target/CC2530USB/: hal_adc.c hal_dma.c hal_flash.c hal_key.c hal_lcd.c hal_led.c hal_sleep.c hal_startup.c hal_timer.c hal_uart.c
  group HAL/Target/CC2530USB/Includes
    ../../../../../Components/hal/target/CC2530USB/: hal_mcu.h hal_types.h
  group HAL/Target/CC2530USB/USB/class_cdc
    ../../../../../Components/hal/target/CC2530USB/usb/class_cdc/: usb_cdc.h usb_cdc_descriptor.s51 usb_cdc_hooks.c usb_cdc_hooks.h usb_firmware_library_config.c usb_firmware_library_config.h usb_firmware_library_headers.h
  group HAL/Target/CC2530USB/USB/library
    ../../../../../Components/hal/target/CC2530USB/usb/library/: usb_descriptor.h usb_descriptor_parser.c usb_descriptor_parser.h usb_framework.c usb_framework.h usb_framework_structs.h usb_interrupt.h usb_reg.h usb_standard_requests.c usb_standard_requests.h usb_suspend.h
  group HAL/Target/CC2530USB/USB/library/cc2531
    ../../../../../Components/hal/target/CC2530USB/usb/library/cc2531/: usb_board_cfg.h usb_interrupt.c usb_suspend.c
  group MAC/High Level
    ../../../../../Components/mac/high_level/: mac_cfg.c mac_high_level.h mac_pib.c mac_pib.h mac_spec.h
  group MAC/High Level/Lib
    ../../../Libraries/cc2530/IAR/bin/Lib/: macLib_cc2530-Banked.lib macLibSec_cc2530-Banked.lib
  group MAC/Include
    ../../../../../Components/mac/include/: mac_api.h
  group MAC/Low Level/Common
    ../../../../../Components/mac/low_level/srf04/: mac_assert.h mac_autopend.c mac_autopend.h mac_backoff_timer.c mac_backoff_timer.h mac_low_level.c mac_low_level.h mac_radio.c mac_radio.h mac_rx.c mac_rx.h mac_rx_onoff.c mac_rx_onoff.h mac_sleep.c mac_sleep.h mac_tx.c mac_tx.h
  group MAC/Low Level/System
    ../../../../../Components/mac/low_level/srf04/single_chip/: mac_csp_tx.c mac_csp_tx.h mac_mcu.c mac_mcu.h mac_mem.c mac_mem.h mac_radio_defs.c mac_radio_defs.h mac_rffrontend.c
  group OSAL
    ../../../../../Components/osal/common/: OSAL.c OSAL_Clock.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Timers.c
    ../../../../../Components/osal/mcu/cc2530/: OSAL_Math.s51
  group Services
    ../../../../../Components/services/saddr/: saddr.c saddr.h
